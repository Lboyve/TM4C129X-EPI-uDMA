# Keil uVision project M4_PLUS_SXT.uvproj, settings and files
target M4_PLUS_SXT (ARM-ADS)
  device: TM4C1290NCPDT Texas Instruments
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0-0xFFFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: M4_PLUS_SXT +hex
  c flags: Optim=3
  c define: rvmdk PART_TM4C1290NCPDT TARGET_IS_SNOWFLAKE_RA0
  c misc: --c99  --gnu
  c include: ..;..\;..\..\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x90000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Startup
    ./: startup_TM4C129.s
  group driverlib
    ../driverlib/: watchdog.c adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c i2c.c interrupt.c lcd.c mpu.c pwm.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c
  group inc
    ../inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h
  group user
    ../user/: main.c myepi.c mygpio.c mytimer0a.c myudma.c
  group utils
    ../utils/: uartstdio.c ustdlib.c
